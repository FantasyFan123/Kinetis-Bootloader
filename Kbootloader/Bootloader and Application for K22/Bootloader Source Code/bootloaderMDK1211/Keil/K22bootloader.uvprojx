# Keil uVision project K22bootloader.uvprojx, settings and files
target K22bootloader (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: K22bootloader +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Common;..\Driver;..\Driver\bootcfg;..\Driver\flash;..\Driver\rs232;..\Sources;..\Startup_Code;..\Keil
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Common
    ../Common/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_cmSimd.h MK22F51212.h system_MK22F51212.h bootloader_asm.s
  group Driver
    ../Driver/bootcfg/: FRDM_K22F_cfg.h
    ../Driver/flash/: flash_kinetis.c flash_kinetis.h
    ../Driver/rs232/: rs232.c rs232.h
  group Source
    ../Sources/: bootloader.c bootloader.h
  group Startup_code
    ../Startup_Code/: startup_MK22F51212.S system_MK22F51212.c
